<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Relative_Channel_Test</value></param>
<param><key>author</key><value>Michael</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Test for VLC channel model with dynamic distance, eission angle, and acceptance angle</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Test flow graph for the VLC channel model</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>my_d</value></param>
<param><key>value</key><value>2</value></param>
<param><key>label</key><value>Distance (m)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>my_phi</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value>Emission Angle (deg)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>90</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>my_psi</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value>Acceptance Angle (deg)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>90</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>vlc_channel_relative</key>
<param><key>id</key><value>vlc_channel_relative_0</value></param>
<param><key>psi</key><value>my_psi</value></param>
<param><key>n</key><value>1</value></param>
<param><key>d</key><value>my_d</value></param>
<param><key>phi</key><value>my_phi</value></param>
<param><key>Ts</key><value>1</value></param>
<param><key>m</key><value>1</value></param>
<param><key>A</key><value>0.001</value></param>
<param><key>R</key><value>1</value></param>
<param><key>FOV</key><value>90</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>vlc_channel_relative_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vlc_channel_relative_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
